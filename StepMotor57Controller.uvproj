# Keil uVision project StepMotor57Controller.uvproj, settings and files
target StepMotor57Controller (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: StepMotor57Controller +hex
  c flags: Optimize=9 SizeSpeed=1
  group master
    ./: stdafx.h main.c delay.c led.c lcd1602.c matrix_keyboard.c atk_remote.c pulse_config.c ui.c README.md
